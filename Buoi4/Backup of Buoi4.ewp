# IAR project Backup of Buoi4.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\WorkingZone\FGA-Traing\Buoi4\user\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: InteruptConfig.c main.c
  group user/inc
    user/inc/: FGAcoursestm8_LCD.h FGAcoursestm8Lib.h
  group user/src
    user/src/: FGAcoursestm8_LCD.c FGAcoursestm8Lib.c
